options:
  parameters:
    generate_options: no_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '457937500'
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: '12500'
  states: {}
- name: data_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: int(samp_rate_audio/data_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"Microphone (USB Audio CODEC )"'
    samp_rate: '48000'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '20'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_audio
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)/10
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '1500'
    decim: '1'
    samp_rate: samp_rate_audio
    taps: firdes.low_pass(1.0,samp_rate_audio,1000,600)
    type: fcf
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
    type: byte
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [audio_source_0, '0', blocks_throttle2_0, '0']
- [blocks_moving_average_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [digital_binary_slicer_fb_0, '0', zeromq_pub_sink_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', digital_clock_recovery_mm_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
